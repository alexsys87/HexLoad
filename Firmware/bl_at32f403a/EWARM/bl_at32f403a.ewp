# IAR project bl_at32f403a.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403ACGU7_v2 ArteryTek -AT32F403ACGU7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F403ACGU7
  ICCARM.CCIncludePath2: ..\App; ..\Drivers\CMSIS\Device\ArteryTek\AT32F403A_407\Include; ..\Drivers\AT32F403A_407_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bl_at32f403a.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: bl_at32f403a.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; AT32F403ACGU7
  group (top)
    ../App/: main.c
    ./: startup.c
