<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\bl_at32f403a.ewp</path>
    </project>
    <batchBuild />
</workspace>
